# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\USART;..\HARDWARE\HONGWAI;..\HARDWARE\HCSR04;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\OLED;..\HARDWARE\EXTI;..\HARDWARE\Gizwits;..\HARDWARE\Utils;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART/: myus.c
    ../HARDWARE/HONGWAI/: hongw.c
    ../HARDWARE/HCSR04/: hcsr.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/OLED/: OLED.c OLED.h OLED_Font.h
    ../HARDWARE/EXTI/: exti.c exti.h
    ../HARDWARE/Gizwits/: gizwits_protocol.c gizwits_product.c
    ../HARDWARE/Utils/: common.c dataPointTools.c ringbuffer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
